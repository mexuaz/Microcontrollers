# Keil uVision project TestPr05.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(100000000) ELITTLE
  output: TestPr05 +hex
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: TestPr05.c am_sevensegment.c
  group ::Device
    RTE/Device/LPC1768/: startup_LPC17xx.s system_LPC17xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
